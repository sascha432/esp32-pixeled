// Text and the clock over an animation (px/effects/overlay.hpp, docs/leds.md section 10).

#include "px/effects/overlay.hpp"

#include <cstddef>

namespace px::effects {

namespace {

// 5 x 7: five columns per character, bit 0 the top row. Printable ASCII from ' ' on.
constexpr uint8_t kFont[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, // ' '
    {0x00, 0x00, 0x5f, 0x00, 0x00}, // !
    {0x00, 0x07, 0x00, 0x07, 0x00}, // "
    {0x14, 0x7f, 0x14, 0x7f, 0x14}, // #
    {0x24, 0x2a, 0x7f, 0x2a, 0x12}, // $
    {0x23, 0x13, 0x08, 0x64, 0x62}, // %
    {0x36, 0x49, 0x55, 0x22, 0x50}, // &
    {0x00, 0x05, 0x03, 0x00, 0x00}, // '
    {0x00, 0x1c, 0x22, 0x41, 0x00}, // (
    {0x00, 0x41, 0x22, 0x1c, 0x00}, // )
    {0x08, 0x2a, 0x1c, 0x2a, 0x08}, // *
    {0x08, 0x08, 0x3e, 0x08, 0x08}, // +
    {0x00, 0x50, 0x30, 0x00, 0x00}, // ,
    {0x08, 0x08, 0x08, 0x08, 0x08}, // -
    {0x00, 0x60, 0x60, 0x00, 0x00}, // .
    {0x20, 0x10, 0x08, 0x04, 0x02}, // /
    {0x3e, 0x51, 0x49, 0x45, 0x3e}, // 0
    {0x00, 0x42, 0x7f, 0x40, 0x00}, // 1
    {0x42, 0x61, 0x51, 0x49, 0x46}, // 2
    {0x21, 0x41, 0x45, 0x4b, 0x31}, // 3
    {0x18, 0x14, 0x12, 0x7f, 0x10}, // 4
    {0x27, 0x45, 0x45, 0x45, 0x39}, // 5
    {0x3c, 0x4a, 0x49, 0x49, 0x30}, // 6
    {0x01, 0x71, 0x09, 0x05, 0x03}, // 7
    {0x36, 0x49, 0x49, 0x49, 0x36}, // 8
    {0x06, 0x49, 0x49, 0x29, 0x1e}, // 9
    {0x00, 0x36, 0x36, 0x00, 0x00}, // :
    {0x00, 0x56, 0x36, 0x00, 0x00}, // ;
    {0x08, 0x14, 0x22, 0x41, 0x00}, // <
    {0x14, 0x14, 0x14, 0x14, 0x14}, // =
    {0x00, 0x41, 0x22, 0x14, 0x08}, // >
    {0x02, 0x01, 0x51, 0x09, 0x06}, // ?
    {0x32, 0x49, 0x79, 0x41, 0x3e}, // @
    {0x7e, 0x11, 0x11, 0x11, 0x7e}, // A
    {0x7f, 0x49, 0x49, 0x49, 0x36}, // B
    {0x3e, 0x41, 0x41, 0x41, 0x22}, // C
    {0x7f, 0x41, 0x41, 0x22, 0x1c}, // D
    {0x7f, 0x49, 0x49, 0x49, 0x41}, // E
    {0x7f, 0x09, 0x09, 0x01, 0x01}, // F
    {0x3e, 0x41, 0x41, 0x51, 0x32}, // G
    {0x7f, 0x08, 0x08, 0x08, 0x7f}, // H
    {0x00, 0x41, 0x7f, 0x41, 0x00}, // I
    {0x20, 0x40, 0x41, 0x3f, 0x01}, // J
    {0x7f, 0x08, 0x14, 0x22, 0x41}, // K
    {0x7f, 0x40, 0x40, 0x40, 0x40}, // L
    {0x7f, 0x02, 0x04, 0x02, 0x7f}, // M
    {0x7f, 0x04, 0x08, 0x10, 0x7f}, // N
    {0x3e, 0x41, 0x41, 0x41, 0x3e}, // O
    {0x7f, 0x09, 0x09, 0x09, 0x06}, // P
    {0x3e, 0x41, 0x51, 0x21, 0x5e}, // Q
    {0x7f, 0x09, 0x19, 0x29, 0x46}, // R
    {0x46, 0x49, 0x49, 0x49, 0x31}, // S
    {0x01, 0x01, 0x7f, 0x01, 0x01}, // T
    {0x3f, 0x40, 0x40, 0x40, 0x3f}, // U
    {0x1f, 0x20, 0x40, 0x20, 0x1f}, // V
    {0x7f, 0x20, 0x18, 0x20, 0x7f}, // W
    {0x63, 0x14, 0x08, 0x14, 0x63}, // X
    {0x03, 0x04, 0x78, 0x04, 0x03}, // Y
    {0x61, 0x51, 0x49, 0x45, 0x43}, // Z
    {0x00, 0x7f, 0x41, 0x41, 0x00}, // [
    {0x02, 0x04, 0x08, 0x10, 0x20}, // backslash
    {0x00, 0x41, 0x41, 0x7f, 0x00}, // ]
    {0x04, 0x02, 0x01, 0x02, 0x04}, // ^
    {0x40, 0x40, 0x40, 0x40, 0x40}, // _
    {0x00, 0x01, 0x02, 0x04, 0x00}, // `
    {0x20, 0x54, 0x54, 0x54, 0x78}, // a
    {0x7f, 0x48, 0x44, 0x44, 0x38}, // b
    {0x38, 0x44, 0x44, 0x44, 0x20}, // c
    {0x38, 0x44, 0x44, 0x48, 0x7f}, // d
    {0x38, 0x54, 0x54, 0x54, 0x18}, // e
    {0x08, 0x7e, 0x09, 0x01, 0x02}, // f
    {0x08, 0x54, 0x54, 0x54, 0x3c}, // g
    {0x7f, 0x08, 0x04, 0x04, 0x78}, // h
    {0x00, 0x44, 0x7d, 0x40, 0x00}, // i
    {0x20, 0x40, 0x44, 0x3d, 0x00}, // j
    {0x7f, 0x10, 0x28, 0x44, 0x00}, // k
    {0x00, 0x41, 0x7f, 0x40, 0x00}, // l
    {0x7c, 0x04, 0x18, 0x04, 0x78}, // m
    {0x7c, 0x08, 0x04, 0x04, 0x78}, // n
    {0x38, 0x44, 0x44, 0x44, 0x38}, // o
    {0x7c, 0x14, 0x14, 0x14, 0x08}, // p
    {0x08, 0x14, 0x14, 0x18, 0x7c}, // q
    {0x7c, 0x08, 0x04, 0x04, 0x08}, // r
    {0x48, 0x54, 0x54, 0x54, 0x20}, // s
    {0x04, 0x3f, 0x44, 0x40, 0x20}, // t
    {0x3c, 0x40, 0x40, 0x20, 0x7c}, // u
    {0x1c, 0x20, 0x40, 0x20, 0x1c}, // v
    {0x3c, 0x40, 0x30, 0x40, 0x3c}, // w
    {0x44, 0x28, 0x10, 0x28, 0x44}, // x
    {0x0c, 0x50, 0x50, 0x50, 0x3c}, // y
    {0x44, 0x64, 0x54, 0x4c, 0x44}, // z
    {0x00, 0x08, 0x36, 0x41, 0x00}, // {
    {0x00, 0x00, 0x7f, 0x00, 0x00}, // |
    {0x00, 0x41, 0x36, 0x08, 0x00}, // }
    {0x08, 0x04, 0x08, 0x10, 0x08}, // ~
};

// the letters beyond ASCII: their code point and columns
struct Extra {
    uint16_t code;
    uint8_t columns[5];
};

constexpr Extra kExtras[] = {
    {0xb0, {0x00, 0x06, 0x09, 0x06, 0x00}}, // degree
    {0xc4, {0x79, 0x14, 0x12, 0x14, 0x79}}, // A umlaut
    {0xd6, {0x39, 0x44, 0x44, 0x44, 0x39}}, // O umlaut
    {0xdc, {0x3d, 0x40, 0x40, 0x40, 0x3d}}, // U umlaut
    {0xdf, {0x7e, 0x01, 0x49, 0x4e, 0x30}}, // sharp s
    {0xe4, {0x20, 0x55, 0x54, 0x55, 0x78}}, // a umlaut
    {0xf6, {0x38, 0x45, 0x44, 0x45, 0x38}}, // o umlaut
    {0xfc, {0x3c, 0x41, 0x40, 0x21, 0x7c}}, // u umlaut
};

constexpr uint8_t kUnknown[5] = {0x02, 0x01, 0x51, 0x09, 0x06}; // ?

// 3 x 5 digits for the clock on a small canvas, bit 0 the top row
constexpr uint8_t kSmallDigits[10][3] = {
    {0x1f, 0x11, 0x1f}, {0x12, 0x1f, 0x10}, {0x1d, 0x15, 0x17}, {0x15, 0x15, 0x1f}, {0x07, 0x04, 0x1f},
    {0x17, 0x15, 0x1d}, {0x1f, 0x15, 0x1d}, {0x01, 0x01, 0x1f}, {0x1f, 0x15, 0x1f}, {0x17, 0x15, 0x1f},
};

// The next character of a UTF-8 text, and the text moved on; 0 at the end. A broken sequence is
// one unknown character.
uint16_t next(const char *&text)
{
    const auto c = static_cast<uint8_t>(*text);
    if (c == 0) {
        return 0;
    }
    text++;
    if (c < 0x80) {
        return c;
    }
    const auto c2 = static_cast<uint8_t>(*text);
    if ((c & 0xe0) == 0xc0 && (c2 & 0xc0) == 0x80) {
        text++;
        return static_cast<uint16_t>((c & 0x1f) << 6 | (c2 & 0x3f));
    }
    // longer sequences: skip their continuation bytes
    while ((static_cast<uint8_t>(*text) & 0xc0) == 0x80) {
        text++;
    }
    return 0xffff;
}

const uint8_t *glyph(uint16_t code)
{
    if (code >= 0x20 && code < 0x7f) {
        return kFont[code - 0x20];
    }
    for (const Extra &e : kExtras) {
        if (e.code == code) {
            return e.columns;
        }
    }
    return kUnknown;
}

// the columns a glyph shows: without the empty ones at its sides; a space is 3 wide
void extent(const uint8_t *columns, uint16_t code, uint8_t &first, uint8_t &width)
{
    if (code == ' ') {
        first = 0;
        width = 3;
        return;
    }
    first = 0;
    while (first < 5 && columns[first] == 0) {
        first++;
    }
    uint8_t last = 5;
    while (last > first && columns[last - 1] == 0) {
        last--;
    }
    width = static_cast<uint8_t>(last - first);
}

void plot(Canvas &canvas, int x, int y, Rgb color)
{
    if (x >= 0 && y >= 0 && x < canvas.width && y < canvas.height) {
        canvas.at(static_cast<uint16_t>(x), static_cast<uint16_t>(y)) = color;
    }
}

// one column of `rows` bits at x, y
void column(Canvas &canvas, uint8_t bits, int rows, int x, int y, Rgb color)
{
    for (int row = 0; row < rows; row++) {
        if ((bits >> row & 1) != 0) {
            plot(canvas, x, y + row, color);
        }
    }
}

} // namespace

uint16_t text_width(const char *text)
{
    uint32_t width = 0;
    bool any = false;
    for (uint16_t code = next(text); code != 0; code = next(text)) {
        uint8_t first = 0, w = 0;
        extent(glyph(code), code, first, w);
        width += w + (any ? 1u : 0u);
        any = true;
    }
    return static_cast<uint16_t>(width > 0xffff ? 0xffff : width);
}

void draw_text(Canvas &canvas, const char *text, int x, int y, Rgb color)
{
    bool any = false;
    for (uint16_t code = next(text); code != 0; code = next(text)) {
        const uint8_t *columns = glyph(code);
        uint8_t first = 0, w = 0;
        extent(columns, code, first, w);
        x += any ? 1 : 0;
        any = true;
        if (x >= canvas.width) {
            return;
        }
        for (uint8_t c = 0; c < w && code != ' '; c++) {
            column(canvas, columns[first + c], kTextHeight, x + c, y, color);
        }
        x += w;
    }
}

int text_x(uint16_t canvas_width, uint16_t width, uint8_t speed, uint32_t ms)
{
    if (width <= canvas_width) {
        return (canvas_width - width) / 2;
    }
    if (speed == 0) {
        return 0;
    }
    // in from the right edge, out at the left, then again
    const uint32_t pixels_per_s = 5u + speed * 45u / 255u;
    const uint32_t way = static_cast<uint32_t>(canvas_width) + width;
    const auto moved = static_cast<uint32_t>(static_cast<uint64_t>(ms) * pixels_per_s / 1000u % way);
    return static_cast<int>(canvas_width) - static_cast<int>(moved);
}

void draw_clock(Canvas &canvas, uint8_t hours, uint8_t minutes, bool colon, Rgb color)
{
    const uint8_t digits[4] = {static_cast<uint8_t>(hours / 10 % 10), static_cast<uint8_t>(hours % 10),
                               static_cast<uint8_t>(minutes / 10 % 10), static_cast<uint8_t>(minutes % 10)};
    // the large font: four digits 5 wide, the colon 2, a pixel between them
    const int large = 4 * 5 + 2 + 4;
    if (large <= canvas.width && kTextHeight <= canvas.height) {
        int x = (canvas.width - large) / 2;
        const int y = (canvas.height - kTextHeight) / 2;
        for (size_t i = 0; i < 4; i++) {
            const uint8_t *columns = kFont['0' + digits[i] - 0x20];
            for (int c = 0; c < 5; c++) {
                column(canvas, columns[c], kTextHeight, x + c, y, color);
            }
            x += 6;
            if (i == 1) {
                column(canvas, colon ? 0x36 : 0, kTextHeight, x, y, color);
                column(canvas, colon ? 0x36 : 0, kTextHeight, x + 1, y, color);
                x += 3;
            }
        }
        return;
    }
    // 3 x 5: four digits, the colon 1, a pixel between them
    const int small = 4 * 3 + 1 + 4;
    int x = (canvas.width - small) / 2;
    const int y = (canvas.height - 5) / 2;
    for (size_t i = 0; i < 4; i++) {
        for (int c = 0; c < 3; c++) {
            column(canvas, kSmallDigits[digits[i]][c], 5, x + c, y, color);
        }
        x += 4;
        if (i == 1) {
            column(canvas, colon ? 0x0a : 0, 5, x, y, color);
            x += 2;
        }
    }
}

} // namespace px::effects
